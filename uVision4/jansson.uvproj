# Keil uVision project jansson.uvproj, settings and files
target CM3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: jansson_cm3 (library)
  AfterMake: xcopy /F /Y "#L" .
  c flags: Optim=3
  group Source
    ../src/: dump.c error.c hashtable.c hashtable_seed.c load.c memory.c pack_unpack.c strbuffer.c strconv.c utf.c value.c
